<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>at91sam7se256_sdram</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>at91sam7se256_flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>at91sam7se256_sram</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>at91sam7se32_sdram</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>at91sam7se32_flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>at91sam7se512_sdram</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>at91sam7se512_flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>at91sam7se512_sram</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>at91lib</name>
    <group>
      <name>boards</name>
      <group>
        <name>at91sam7se-ek</name>
        <group>
          <name>at91sam7se256</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se256\AT91SAM7SE256.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se256\flash.icf</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se256\sdram.icf</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se256\sram.icf</name>
          </file>
        </group>
        <group>
          <name>at91sam7se32</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se32\AT91SAM7SE32.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se32\flash.icf</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se32\sdram.icf</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se32\sram.icf</name>
          </file>
        </group>
        <group>
          <name>at91sam7se512</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se512\AT91SAM7SE512.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se512\flash.icf</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se512\sdram.icf</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se512\sram.icf</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\board.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\board_cstartup_iar.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\board_lowlevel.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\board_memories.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\boards\at91sam7se-ek\board_memories.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>memories</name>
      <group>
        <name>nandflash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\EccNandFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\EccNandFlash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\ManagedNandFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\ManagedNandFlash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\MappedNandFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\MappedNandFlash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\NandCommon.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\NandFlashModel.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\NandFlashModel.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\NandFlashModelList.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\NandFlashModelList.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\NandSpareScheme.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\NandSpareScheme.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\RawNandFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\RawNandFlash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\SkipBlockNandFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\SkipBlockNandFlash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\TranslatedNandFlash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\nandflash\TranslatedNandFlash.h</name>
        </file>
      </group>
      <group>
        <name>norflash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashAmd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashAmd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashApi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashApi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashCFI.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashCFI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashCommon.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashCommon.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashIntel.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\norflash\NorFlashIntel.h</name>
        </file>
      </group>
      <group>
        <name>spi-flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\at26.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\at26.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\at26d.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\at26d.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\at45.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\at45.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\at45d.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\at45d.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\spid.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\memories\spi-flash\spid.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>peripherals</name>
      <group>
        <name>aic</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\aic\aic.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\aic\aic.h</name>
        </file>
      </group>
      <group>
        <name>cp15</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\cp15\cp15.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\cp15\cp15.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\cp15\cp15_asm_iar.s</name>
        </file>
      </group>
      <group>
        <name>dbgu</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\dbgu\dbgu.h</name>
        </file>
      </group>
      <group>
        <name>pio</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\pio\pio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\pio\pio.h</name>
        </file>
      </group>
      <group>
        <name>pit</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\pit\pit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\pit\pit.h</name>
        </file>
      </group>
      <group>
        <name>pmc</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\pmc\pmc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\pmc\pmc.h</name>
        </file>
      </group>
      <group>
        <name>spi</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\spi\spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\spi\spi.h</name>
        </file>
      </group>
      <group>
        <name>tc</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\tc\tc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\tc\tc.h</name>
        </file>
      </group>
      <group>
        <name>usart</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\usart\usart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\at91lib\peripherals\usart\usart.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>utility</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\at91lib\utility\assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\at91lib\utility\hamming.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\at91lib\utility\hamming.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\at91lib\utility\math.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\at91lib\utility\math.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\at91lib\utility\trace.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>basic-usart-hw-handshaking-project</name>
    <file>
      <name>$PROJ_DIR$\..\Download.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Download.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LED_Display.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\LED_Display.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\NorFlash.H</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\printf_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SPI_FUN.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SPI_FUN.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\UART.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\UART.h</name>
    </file>
  </group>
  <group>
    <name>documentation</name>
    <file>
      <name>$EW_DIR$\arm\examples\Atmel\documentation\index.html</name>
    </file>
  </group>
  <group>
    <name>resources</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7a3-ek-flash.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7a3-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7s-ek-flash.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7s-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7se-ek-flash.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7se-ek-sdram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7se-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7x-ek-flash.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7x-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7xc-ek-flash.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam7xc-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9260-ek-norflash.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9260-ek-sdram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9260-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9263-ek-sdram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9263-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9g20-ek-norflash.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9g20-ek-sdram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9g20-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9m10-ek-ddram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9m10-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9rl-ek-sdram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9rl-ek-sram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9xe-ek-flash.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9xe-ek-sdram.mac</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\resources\iar\at91sam9xe-ek-sram.mac</name>
    </file>
  </group>
</project>


