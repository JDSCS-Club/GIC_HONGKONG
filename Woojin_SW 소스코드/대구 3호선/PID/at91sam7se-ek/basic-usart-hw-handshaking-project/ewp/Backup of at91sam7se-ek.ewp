# IAR project Backup of at91sam7se-ek.ewp, settings and files
configuration at91sam7se256_sdram (ARM, debug)
  General.OGChipSelectEditMenu: at91sam7se256 Atmel at91sam7se256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: at91sam7se256; sdram; TRACE_LEVEL=4
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib; ..\..\..\at91lib/components; ..\..\..\at91lib/boards/at91sam7se-ek
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: at91sam7se256; sdram; TRACE_LEVEL=4
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7se-ek
  OBJCOPY.OOCOutputFile: at91sam7se256_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se256_sdram.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se256\sdram
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam7se256_flash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7se256; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se256; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se256_flash.bin
  ILINK.IlinkOutputFile: at91sam7se256_flash.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se256\flash
configuration at91sam7se256_sram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: at91sam7se256; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se256; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se256_sram.bin
  ILINK.IlinkOutputFile: at91sam7se256_sram.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se256\sram
configuration at91sam7se32_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se32 Atmel at91sam7se32
  ICCARM.CCDefines: at91sam7se32; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se32; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se32_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se32_sdram.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se32\sdram
configuration at91sam7se32_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se32 Atmel at91sam7se32
  ICCARM.CCDefines: at91sam7se32; flash; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se32; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se32_flash.bin
  ILINK.IlinkOutputFile: at91sam7se32_flash.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se32\flash
configuration at91sam7se512_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Atmel at91sam7se512
  ICCARM.CCDefines: at91sam7se512; sdram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se512; sdram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_sdram.bin
  ILINK.IlinkOutputFile: at91sam7se512_sdram.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se512\sdram
configuration at91sam7se512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT91SAM7SE512 Atmel AT91SAM7SE512
  ICCARM.CCDefines: at91sam7se512; flash; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: ..\..\..\at91lib/peripherals; ..\..\..\at91lib/memories; ..\..\..\at91lib; ..\..\..\at91lib/components; ..\..\..\at91lib/boards/at91sam7se-ek
  ICCARM.CCOptLevel: 0
  AARM.ADefines: at91sam7se512; flash; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_flash.bin
  ILINK.IlinkOutputFile: at91sam7se512_flash.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se512\flash
configuration at91sam7se512_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam7se512 Atmel at91sam7se512
  ICCARM.CCDefines: at91sam7se512; sram; TRACE_LEVEL=4
  AARM.ADefines: at91sam7se512; sram; TRACE_LEVEL=4
  OBJCOPY.OOCOutputFile: at91sam7se512_sram.bin
  ILINK.IlinkOutputFile: at91sam7se512_sram.out
  ILINK.IlinkIcfFile: ..\..\..\at91lib\boards\at91sam7se-ek\at91sam7se512\sram
  group at91lib/boards/at91sam7se-ek
    ../../../at91lib/boards/at91sam7se-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_memories.c board_memories.h
  group at91lib/boards/at91sam7se-ek/at91sam7se256
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se256/: AT91SAM7SE256.h flash.icf sdram.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se32
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se32/: AT91SAM7SE32.h flash.icf sdram.icf sram.icf
  group at91lib/boards/at91sam7se-ek/at91sam7se512
    ../../../at91lib/boards/at91sam7se-ek/at91sam7se512/: AT91SAM7SE512.h flash.icf sdram.icf sram.icf
  group at91lib/memories/nandflash
    ../../../at91lib/memories/nandflash/: EccNandFlash.c EccNandFlash.h ManagedNandFlash.c ManagedNandFlash.h MappedNandFlash.c MappedNandFlash.h NandCommon.h NandFlashModel.c NandFlashModel.h NandFlashModelList.c NandFlashModelList.h NandSpareScheme.c NandSpareScheme.h RawNandFlash.c RawNandFlash.h SkipBlockNandFlash.c SkipBlockNandFlash.h TranslatedNandFlash.c TranslatedNandFlash.h
  group at91lib/memories/norflash
    ../../../at91lib/memories/norflash/: NorFlashAmd.c NorFlashAmd.h NorFlashApi.c NorFlashApi.h NorFlashCFI.c NorFlashCFI.h NorFlashCommon.c NorFlashCommon.h NorFlashIntel.c NorFlashIntel.h
  group at91lib/memories/spi-flash
    ../../../at91lib/memories/spi-flash/: at26.c at26.h at26d.c at26d.h at45.c at45.h at45d.c at45d.h spid.c spid.h
  group at91lib/peripherals/aic
    ../../../at91lib/peripherals/aic/: aic.c aic.h
  group at91lib/peripherals/cp15
    ../../../at91lib/peripherals/cp15/: cp15.c cp15.h cp15_asm_iar.s
  group at91lib/peripherals/dbgu
    ../../../at91lib/peripherals/dbgu/: dbgu.h
  group at91lib/peripherals/pio
    ../../../at91lib/peripherals/pio/: pio.c pio.h
  group at91lib/peripherals/pit
    ../../../at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/pmc
    ../../../at91lib/peripherals/pmc/: pmc.c pmc.h
  group at91lib/peripherals/spi
    ../../../at91lib/peripherals/spi/: spi.c spi.h
  group at91lib/peripherals/tc
    ../../../at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/peripherals/usart
    ../../../at91lib/peripherals/usart/: usart.c usart.h
  group at91lib/utility
    ../../../at91lib/utility/: assert.h hamming.c hamming.h math.c math.h trace.h
  group basic-usart-hw-handshaking-project
    ../: Download.c Download.h LED_Display.c LED_Display.h main.c main.h NorFlash.H printf_usart.c SPI_FUN.c SPI_FUN.h UART.c UART.h
  group documentation
    $EW_DIR$/arm/examples/Atmel/documentation/: index.html
  group resources
    ../../../resources/iar/: at91sam7a3-ek-flash.mac at91sam7a3-ek-sram.mac at91sam7s-ek-flash.mac at91sam7s-ek-sram.mac at91sam7se-ek-flash.mac at91sam7se-ek-sdram.mac at91sam7se-ek-sram.mac at91sam7x-ek-flash.mac at91sam7x-ek-sram.mac at91sam7xc-ek-flash.mac at91sam7xc-ek-sram.mac at91sam9260-ek-norflash.mac at91sam9260-ek-sdram.mac at91sam9260-ek-sram.mac at91sam9263-ek-sdram.mac at91sam9263-ek-sram.mac at91sam9g20-ek-norflash.mac at91sam9g20-ek-sdram.mac at91sam9g20-ek-sram.mac at91sam9m10-ek-ddram.mac at91sam9m10-ek-sram.mac at91sam9rl-ek-sdram.mac at91sam9rl-ek-sram.mac at91sam9xe-ek-flash.mac at91sam9xe-ek-sdram.mac at91sam9xe-ek-sram.mac
